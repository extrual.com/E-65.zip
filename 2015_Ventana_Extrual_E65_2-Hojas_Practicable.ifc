Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2017-08-03T11:36:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 15.6.0.0 - Alternate UI 15.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Aug 03 11:36:18 2017 * Host: Bestia-01 * Database: C:\Users\CARLOS~1\AppData\Local\Temp\{1EF966B3-6EE3-46E0-AD63-142BD68F4FE7}\ifc * Database version: 5507 * Database creation date: Thu Aug 03 11:36:17 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Aug 03 11:36:18 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Aug 03 11:36:18 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 40, 23, 59, 999999; RefLongitude: -3, -40, -59, -879999; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuildingStorey, Nivel 1
LongName: Nivel 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Extremo inicial 8 mm; Family and Type: Level: Extremo inicial 8 mm; Type: Level: Extremo inicial 8 mm; Type Id: Level: Extremo inicial 8 mm
Identity Data - Type Name: Extremo inicial 8 mm; Building Story: yes; Name: Nivel 1; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: Extremo inicial de nivel - Círculo: Extremo inicial de nivel - Círculo; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcWindow: 1200x1200 mm Practicable, 2015_Ventana_Extrual_E65_2-Hojas_Practicable-Oscilobatiente:1200x1200 mm Practicable:131632
In: Nivel 1
Type - ParameterTakesPrecedence: no; Sizeable: no; Material: Cristal - Vidrio claro templado, Aluminio
Type - Analysis Results - FactorSolarModificado: 3000000; FactorSombra: 0; FraccionAreaAcristalamiento: 0.636075; Y𝑔 P1: 0.47; Y𝑔 P2: 0.47; 𝐴𝑓 P1: 383216; 𝐴𝑓 P2: 140836; 𝐴𝑔 V1: 457974; 𝐴𝑔 V2: 457974; 𝑈𝑓 P1: 2.42; 𝑈𝑓 P2: 3.039; 𝑈𝑔 V1: 1; 𝑈𝑔 V2: 1; 𝑈𝑤: 1.76969; 𝑙𝑔 P1: 3838; 𝑙𝑔 P2: 2056
Type - Analytical Properties - Analytic Construction: <None>
Type - Construction - Altura de antepecho por defecto: 800 mm; CerramientoExterior: yes; ConfiguracionPoliamidas: 489900 - 479800 - 490000; ControlHumos: no; Motorizada: no; RepisaExterior: yes; RepisaInterior: yes; SalidaEmergencia: no; Wall Closure: By host
Type - Data - Area: 1.44 m2; EstanqueidadAgua: E1200; IndiceGlobalRedAcustica: Hasta Rw=46 dB; MasaSuperficialKgm2: 0; PermeabilidadAlAire: CLASE 4; ResistenciaAlViento: C5; TransmitanciaTermica: 2
Type - Dimensions - Altura Máxima: 2700 mm; Altura Real: 1200 mm; AnchoMarco: 86 mm; AnchoMarcoCentral: 137 mm; Anchura Máxima: 1700 mm; Anchura Real: 1200 mm; Desfase Acristalamiento: 13.5 mm; GrosorAcristalamiento: 32 mm; GrosorMarco: 72 mm; Height: 1200 mm; MaximoAcristalamiento: 60 mm; Perimetro: 4800; ProfundidadCristalenMarco: 26.01 mm; Rough Height: 1205 mm; Rough Width: 1205 mm; Width: 1200 mm
Type - General - CosteMantenimiento: 0; MateriaPrima: 0
Type - Green Building Properties - AcidificacionAtmosferica: 0; AcidificacionAtmosfericaPorUnidad: 0; AguaConsumida: 0; AguaConsumidaPorUnidad: 0; CambioClimatico: 0; CambioClimaticoPorUnidad: 0; CosteEnergeticoKwh: 0; CosteEnergeticoMj: 0; DestruccionCapaOzonoEstratosferica: 0; DestruccionCapaOzonoEstratosfericaPorUnidad: 0; EmisionCO2: 0; EnergiaNoRenovableConsumida: 0; EnergiaNoRenovableConsumidaPorUnidad: 0; EnergiaPrimariaTotalConsumida: 0; EnergiaPrimariaTotalConsumidaPorUnidad: 0; EnergiaRenovableConsumida: 0; EnergiaRenovableConsumidaPorUnidad: 0; Eutrofizacion: 0; EutrofizacionPorUnidad: 0; FaltaDeRecursos: 0; FaltaDeRecursosPorUnidad: 0; FormacionFotoquimicaOzono: 0; FormacionFotoquimicaOzonoPorUnidad: 0; ResiduoInerte: 0; ResiduoInertePorUnidad: 0; ResiduoRadioactivo: 0; ResiduoRadioactivoPorUnidad: 0; ResiduosNoPeligrosos: 0; ResiduosNoPeligrososPorUnidad: 0; ResiduosPeligrosos: 0; ResiduosPeligrososPorUnidad: 0; VidaUtilEsperada: >50 Years
Type - Identity Data - Autor: Bimetica Parametric Design Services, S.L.; Bimetica: http://www.bimetica.com; Description: Ventana 2 Hojas Practicable; DuracionVidaUtil: >50 Years; EmailContacto: extrual@extrual.com; FechaEmisionElementoBIM: 31/07/2017; FechaVencimientoElementoBIM: 31/07/2018; GarantiaExtendida: no; InformacionTecnica: http://www.extrual.com/es/sistemas-extrual/practicables/practicables-canal-europeo/e-65/at_download/ficha_tecnica; Manufacturer: Extrual; MasterformatCodigo: 08 51 13; MasterformatTitulo: Aluminium Windows; Model: E-65 Hojas Practicable; OmniclassCodigo: 23.30.20.17.21.21; OmniClass Number: 23.30.20.00; OmniClass Title: Windows; OmniclassTitulo: Casment Window; ReferenciaContacto: Extrual; TelefonoContacto: +34 967 21 66 62 - 21; Type Comments: Sistema de Ventana, Balconera y Puerta con Rotura de Puente Térmico, estética de lineas rectas y altas prestaciones térmicas y acústicas proporcionadas por espumas y poliamidas tubulares gracias a los 65 mm. de ancho de marco.; Type Mark: 23; Type Name: 1200x1200 mm Practicable; Uniclass2.0Codigo: 25-30; Uniclass2.0Titulo: Door and window systems; UNSPSCCodigo: 30171600; UNSPSCTitulo: Windows; URL: http://www.extrual.com/; URL Poliamida: http://www.technoform.es/; URL Poliamida - Catálogo: http://www.technoform.com/fileadmin/Technoform_Bautec/standardprofiles.html; URLProducto: http://www.extrual.com/es/sistemas-extrual/practicables/practicables-canal-europeo/e-65; VersionElementoBIM: 1.1
Type - Materials and Finishes - Acristalamiento: Cristal - Vidrio claro templado; Marco: Aluminio; Poliamida: Poliamida, Technoform Bautec, PA66 GF 25
Type - Other - Category: Windows; a: 2548349; Family Name: 2015_Ventana_Extrual_E65_2-Hojas_Practicable-Oscilobatiente
Type - Visibility - Oscilobatiente: no; Practicable: yes
OverallHeight: 1200 mm; OverallWidth: 1200 mm
Pset_WindowCommon - Reference: 1200x1200 mm Practicable; IsExternal: yes
Pset_ManufacturerTypeInformation - Manufacturer: Extrual
Constraints - Level: Level: Nivel 1; Sill Height: 500 mm
Dimensions - Area: 2.86577 m2; DesfaseExterior: 0 mm; DesfaseInterior: 0 mm; Volume: 0.0581114 m3
Identity Data - Mark: 1
Other - Family: 2015_Ventana_Extrual_E65_2-Hojas_Practicable-Oscilobatiente: 1200x1200 mm Practicable; Family and Type: 2015_Ventana_Extrual_E65_2-Hojas_Practicable-Oscilobatiente: 1200x1200 mm Practicable; Head Height: 1700 mm; Host Id: Basic Wall: Exterior - Ladrillo en entramado metálico; Type: 2015_Ventana_Extrual_E65_2-Hojas_Practicable-Oscilobatiente: 1200x1200 mm Practicable; Type Id: 2015_Ventana_Extrual_E65_2-Hojas_Practicable-Oscilobatiente: 1200x1200 mm Practicable
Phasing - Phase Created: Fase 1
Visibility - Aperturas: yes; Aperturas Oscilobatiente: no; DetalleCarpinteria: yes; Manija: yes
